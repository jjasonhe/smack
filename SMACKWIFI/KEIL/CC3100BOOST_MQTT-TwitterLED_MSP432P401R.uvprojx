# Keil uVision project CC3100BOOST_MQTT-TwitterLED_MSP432P401R.uvprojx, settings and files
target CC3100BOOST_MQTT-TwitterLED_MSP432P401R (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.2.1
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CC3100BOOST_MQTT-TwitterLED_MSP432P401R
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil _USE_CLI_
  c include: ..;..\board;..\cli_uart;..\driverlib\MSP432P4xx;..\mqtt;..\simplelink;..\simplelink\include;..\simplelink\source;..\spi_cc3100;..\uart_cc3100
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ../: main.c Butts.c Dets.c LCD.c Locks.c Keypad.c
  group board
    ../board/: board.c
  group cli_uart
    ../cli_uart/: cli_uart.c
  group driverlib
    ../driverlib/MSP432P4xx/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group mqtt
    ../mqtt/: MQTTCC3100.c MQTTClient.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group simplelink
    ../simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
  group spi_cc3100
    ../spi_cc3100/: spi_cc3100.c
  group uart_cc3100
    ../uart_cc3100/: uart_cc3100.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.2
